# Keil uVision project T12.uvproj, settings and files
target I2C (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: T12 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c iic.c sys.c mpu6050.c
